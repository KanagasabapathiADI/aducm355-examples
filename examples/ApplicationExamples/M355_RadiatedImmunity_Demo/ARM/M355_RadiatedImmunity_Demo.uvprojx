# Keil uVision project M355_RadiatedImmunity_Demo.uvprojx, settings and files
target Debug (6220000::V6.22::ARMCLANG)
  device: ADuCM355 Analog Devices
  pack: AnalogDevices.ADuCM355_DFP.2.2.0
  cpu: IRAM(0x20000000,0x02000) IRAM2(0x20002000,0x02000) IROM(0x00000000,0x20000) XRAM(0x20004000,0x04000) XRAM2(0x20040000,0x08000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M355_RadiatedImmunity_Demo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CHIPSEL_M355
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x20004000 size 0x4000
  memory RVCT7: RAM 0x20040000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x2000
  group app
    ../: AD5940Main.c M355_EMCFlash.c main.c RadiatedImmunity_Demo.c
    ./: Readme_M355_RadiatedImmunity_Demo.txt
target Release (6220000::V6.22::ARMCLANG)
  device: ADuCM355 Analog Devices
  pack: AnalogDevices.ADuCM355_DFP.2.2.0
  cpu: as above
  output: M355_RadiatedImmunity_Demo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CHIPSEL_M355
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x20004000 size 0x4000
  memory RVCT7: RAM 0x20040000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 6.2.0, Device:AFE:Operation 2.0.0, Device:Peripheral Libraries:CLOCK 2.0.0, Device:Peripheral Libraries:FLASH 2.0.0, Device:Peripheral Libraries:GPIO 2.0.0, Device:Peripheral Libraries:INT 2.0.0, Device:Peripheral Libraries:PWR 2.0.0, Device:Peripheral Libraries:RST 2.0.0, Device:Peripheral Libraries:UART 2.0.0, Device:Retarget UART 2.0.0, Device:Startup 2.0.0, Compiler:I/O:STDOUT 1.2.0
